MYDATA SEGMENT CODE
RSEG MYDATA
STR: DB 0X32,0XFE,0X49,0X29,0X03,0X10,0XFF,0X4F,0X9A,0X64

CSEG AT 0
MOV DPTR,#STR
MOV R0,#10
MOV R1,#30H
MOV R2,#0
COPY:
MOV A,R2
MOVC A,@A+DPTR
XCH A,@R1
INC R1
INC R2
DJNZ R0,COPY
;ALL DATA COPIED TO SCRATCH PAD AREA

MOV R3,#9	;counter for inner loop
MOV R4,#9	;counter for outer loop

OUTER_LOOP:
MOV R0,#30H
MOV R1,#31H

INNER_LOOP:
MOV A,@R0
SUBB A,@R1
JNC EXCHANGE

GO:
INC R0
INC R1
DJNZ R3,INNER_LOOP

MOV 03H,R4
DEC R3
DJNZ R4,OUTER_LOOP

SJMP LAST
EXCHANGE:
MOV A,@R0
XCH A,@R1
MOV @R0,A
SJMP GO

LAST:
SJMP $
END
